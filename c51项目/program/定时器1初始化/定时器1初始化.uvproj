# Keil uVision project 定时器1初始化.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 定时器1初始化 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Objects/code/: main.c c51tangsang.c c51tangsang.h
