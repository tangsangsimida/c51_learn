# Keil uVision project 秒表.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 秒表 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Objects/code/: c51tangsang.c c51tangsang.h LCD1602_b.c LCD1602_b.h REG52.H main.c
