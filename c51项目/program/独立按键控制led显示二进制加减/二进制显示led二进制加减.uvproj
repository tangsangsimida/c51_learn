# Keil uVision project 二进制显示led二进制加减.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 二进制显示led二进制加减 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Objects/code/: main.c c51tangsang.h c51tangsang.c
