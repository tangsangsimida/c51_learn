# Keil uVision project program.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: program +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./code/: main.c c51tangsang.c c51tangsang.h the_auto_turn_where.c the_auto_turn_where.h
