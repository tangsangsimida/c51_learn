# Keil uVision project 点阵画图.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 点阵画图 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\lib\tangsanglib
  group Source Group 1
    ./Objects/code/: main.c c51tangsang.c c51tangsang.h
