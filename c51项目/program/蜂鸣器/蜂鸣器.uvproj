# Keil uVision project 蜂鸣器.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 蜂鸣器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Objects/code/: c51tangsang.c c51tangsang.h main.c lcd1602.c public.c lcd1602.h public.h
