# Keil uVision project 温度传感器.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 温度传感器
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./code/: c51tangsang.c c51tangsang.h LCD1602_b.c LCD1602_b.h main.c
